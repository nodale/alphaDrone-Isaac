Commit message: updated fly_boy physical properties

File: alphaDroneClean/fly_boy/fly_boy.urdf (robot description, URDF)
Before this commit: robot quadrotor, 5 links, 4 joints
Links:
- link base_link: mass 3.650 -> 3.683
